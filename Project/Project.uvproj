# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\FWLib\inc;..\CORE;..\User;..\HARDWARE;..\SYSTEM;..\APP;..\HARDWARE\USART
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../User/: main.c stm32f0xx_it.c system_stm32f0xx.c
    ../CORE/: startup_stm32f030x8.s
  group FWLIB
    ../FWLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group SYSTEM
    ../SYSTEM/: hal_delay.c hal_sys.c hal_GPIO.c hal_TIMx.c hal_PWM.c
  group HABDWARE
    ../HARDWARE/USART/: USART.c Serial.c
